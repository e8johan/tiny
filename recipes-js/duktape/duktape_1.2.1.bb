require ${PN}.inc

SRC_URI = "http://duktape.org/duktape-1.2.1.tar.xz"
SRC_URI[md5sum] = "86362304a347fd88bcbcdfc00ff3663c"
SRC_URI[sha256sum] = "5bee9371ef60acf5af95925d5787c9a5ccd1955ada373504b36dc1d640c0b74a"

PV = "1.2.1"